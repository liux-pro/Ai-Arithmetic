# Keil uVision project Ai-Arithmetic.uvproj, settings and files
target Ai-Arithmetic (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: Ai-Arithmetic +hex
  group source
    ./: main.c expression.c expression.h touch.c touch.h backLight.c Ai.c canvas.c delay.c
  group library
    ./library/: STC32G_PWM.c
  group usb
    ./usb/: stc.h usb.c usb.h usb_desc.c usb_desc.h usb_req_class.c usb_req_class.h usb_req_std.c usb_req_std.h usb_req_vendor.c usb_req_vendor.h util.c util.h uart.c uart.h
  group lcd
    ./lcd/: FONT.H LCD.c LCD.h
  group TinyMaix
    ./TinyMaix/: arch_cpu.h tinymaix.h tm_layers.c tm_model.c tm_port.h tm_stat.c
