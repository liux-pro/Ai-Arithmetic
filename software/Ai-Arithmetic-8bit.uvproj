# Keil uVision project Ai-Arithmetic-8bit.uvproj, settings and files
target Ai-Arithmetic (MCS-51)
  device: AI8051U-8Bit Series AI
  cpu: IRAM(0-0xFF) XRAM(0-0x7FFF) IROM(0-0xFFFF) CLOCK(35000000)
  output: Ai-Arithmetic-8bit +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: usb;library;lcd;TinyMaix
  link misc: NOOVERLAY
  group source
    ./: main.c expression.h touch.c touch.h backLight.c canvas.c delay.c Ai.c expression.c
  group library
    ./library/: STC32G_PWM.c
  group usb
    ./usb/: stc.h usb.c usb.h usb_desc.c usb_desc.h usb_req_class.c usb_req_class.h usb_req_std.c usb_req_std.h usb_req_vendor.c usb_req_vendor.h util.c util.h uart.c uart.h
  group lcd
    ./lcd/: FONT.H LCD.c LCD.h
  group TinyMaix
    ./TinyMaix/: arch_cpu.h tinymaix.h tm_port.h tm_layers.c tm_model.c tm_stat.c
